FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += "file://0001-linux-user-remove-host-stime-syscall.patch"
