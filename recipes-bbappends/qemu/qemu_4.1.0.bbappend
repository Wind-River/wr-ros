FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-linux-user-remove-host-stime-syscall.patch"
