FILES_${PN} += "${nonarch_libdir}/lib*.so ${datadir}/lib"
