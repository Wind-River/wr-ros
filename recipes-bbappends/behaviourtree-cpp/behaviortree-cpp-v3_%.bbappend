FILES_${PN}-dev += "${nonarch_libdir}/BehaviorTreeV3"
