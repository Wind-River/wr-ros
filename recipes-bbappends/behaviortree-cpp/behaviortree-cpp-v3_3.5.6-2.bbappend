FILES_${PN} += "${nonarch_libdir}/lib*.so"
FILES_${PN}-dev += "${nonarch_libdir}/BehaviorTreeV3"
