LICENSE = "GPL-2.0+"
SRC_URI = "https://github.com/libstatgrab/libstatgrab/releases/download/LIBSTATGRAB_0_91/libstatgrab-0.91.tar.gz"
