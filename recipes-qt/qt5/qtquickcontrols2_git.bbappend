BBCLASSEXTEND =+ "native"
PROVIDES += "${PN}-mkspecs"
RPROVIDES_append_class-native = " qtquickcontrols2-mkspecs-native"
