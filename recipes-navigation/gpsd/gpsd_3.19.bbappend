LDFLAGS += " -lpthread "
